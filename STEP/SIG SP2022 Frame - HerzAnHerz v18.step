STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'E:/Repos/SP2022-MadamaButterfly/STEP/SIG SP2022 Frame - Madama Butterfly v18.step',/* time_stamp */ '2021-01-23T03:13:48-05:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v9.7.1.1290',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): SIG SP2022 Frame - Vinh's Fixes
Bounding box: 31.3 x 173.38 x 96 mm (x, y, z)
Volume: 58534.6 mm3; surface area: 43850.8 mm2
Topology: 1 solids, 1 shells, 581 faces, 1671 edges, 1070 vertices
Faces by surface type: plane 283, bspline 163, cylinder 125, torus 8, sphere 2
Full cylindrical faces by diameter (mm): 2 x1, 2.8 x1, 3.6 x2, 3.7 x2, 4 x2, 4.55 x2
Entity records: 29136 total; most frequent: CARTESIAN_POINT 15322, ORIENTED_EDGE 3326, DIRECTION 2170, EDGE_CURVE 1663, VERTEX_POINT 1068, LINE 898, VECTOR 898, AXIS2_PLACEMENT_3D 636
