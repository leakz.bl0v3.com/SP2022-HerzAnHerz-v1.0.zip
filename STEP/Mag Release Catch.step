STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'E:/Repos/SP2022-MadamaButterfly/STEP/Mag Release Catch.step',/* time_stamp */ '2021-01-23T03:07:23-05:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v9.7.1.1290',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Mag Release Catch
Bounding box: 5 x 10.9 x 4.4 mm (x, y, z)
Volume: 103.3 mm3; surface area: 225 mm2
Topology: 1 solids, 1 shells, 24 faces, 64 edges, 43 vertices
Faces by surface type: plane 19, cylinder 5
Entity records: 833 total; most frequent: CARTESIAN_POINT 181, ORIENTED_EDGE 128, DIRECTION 123, EDGE_CURVE 64, LINE 53, VECTOR 53, VERTEX_POINT 43, AXIS2_PLACEMENT_3D 35
