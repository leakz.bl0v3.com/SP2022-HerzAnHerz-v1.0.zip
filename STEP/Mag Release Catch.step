One B-rep face of a CAD part: STEP entity #445.
In plain terms, the planar face has unit normal (0, -0.951, 0.308).
Its self-contained STEP definition (entity closure, numbers rounded to 3 decimals):
#16=ELLIPSE('',#488,1.866,1.775);
#21=PLANE('',#487);
#52=LINE('',#729,#105);
#53=LINE('',#731,#106);
#54=LINE('',#733,#107);
#55=LINE('',#735,#108);
#56=LINE('',#737,#109);
#57=LINE('',#741,#110);
#58=LINE('',#742,#111);
#105=VECTOR('',#547,10.);
#106=VECTOR('',#548,10.);
#107=VECTOR('',#549,10.);
#108=VECTOR('',#550,10.);
#109=VECTOR('',#551,10.);
#110=VECTOR('',#554,10.);
#111=VECTOR('',#555,10.);
#155=FACE_OUTER_BOUND('',#179,.T.);
#179=EDGE_LOOP('',(#330,#331,#332,#333,#334,#335,#336,#337));
#218=VERTEX_POINT('',#727);
#219=VERTEX_POINT('',#728);
#220=VERTEX_POINT('',#730);
#221=VERTEX_POINT('',#732);
#222=VERTEX_POINT('',#734);
#223=VERTEX_POINT('',#736);
#224=VERTEX_POINT('',#738);
#225=VERTEX_POINT('',#740);
#263=EDGE_CURVE('',#218,#219,#52,.T.);
#264=EDGE_CURVE('',#220,#218,#53,.T.);
#265=EDGE_CURVE('',#221,#220,#54,.T.);
#266=EDGE_CURVE('',#222,#221,#55,.T.);
#267=EDGE_CURVE('',#223,#222,#56,.T.);
#268=EDGE_CURVE('',#224,#223,#16,.T.);
#269=EDGE_CURVE('',#225,#224,#57,.T.);
#270=EDGE_CURVE('',#219,#225,#58,.T.);
#330=ORIENTED_EDGE('',*,*,#263,.F.);
#331=ORIENTED_EDGE('',*,*,#264,.F.);
#332=ORIENTED_EDGE('',*,*,#265,.F.);
#333=ORIENTED_EDGE('',*,*,#266,.F.);
#334=ORIENTED_EDGE('',*,*,#267,.F.);
#335=ORIENTED_EDGE('',*,*,#268,.F.);
#336=ORIENTED_EDGE('',*,*,#269,.F.);
#337=ORIENTED_EDGE('',*,*,#270,.F.);
#445=ADVANCED_FACE('',(#155),#21,.F.);
#487=AXIS2_PLACEMENT_3D('',#726,#545,#546);
#488=AXIS2_PLACEMENT_3D('',#739,#552,#553);
#545=DIRECTION('center_axis',(0.,0.951,-0.308));
#546=DIRECTION('ref_axis',(0.,0.308,0.951));
#547=DIRECTION('',(0.,0.308,0.951));
#548=DIRECTION('',(-1.,0.,0.));
#549=DIRECTION('',(0.,-0.308,-0.951));
#550=DIRECTION('',(-1.,0.,0.));
#551=DIRECTION('',(0.483,-0.27,-0.833));
#552=DIRECTION('center_axis',(0.,0.951,-0.308));
#553=DIRECTION('ref_axis',(0.,-0.308,-0.951));
#554=DIRECTION('',(0.483,0.27,0.833));
#555=DIRECTION('',(-1.,0.,0.));
#726=CARTESIAN_POINT('Origin',(1.9,9.7,0.));
#727=CARTESIAN_POINT('',(-1.9,9.7,0.));
#728=CARTESIAN_POINT('',(-1.9,10.024,1.));
#729=CARTESIAN_POINT('',(-1.9,9.7,0.));
#730=CARTESIAN_POINT('',(1.9,9.7,0.));
#731=CARTESIAN_POINT('',(1.9,9.7,0.));
#732=CARTESIAN_POINT('',(1.9,10.024,1.));
#733=CARTESIAN_POINT('',(1.9,9.847,0.453));
#734=CARTESIAN_POINT('',(2.5,10.024,1.));
#735=CARTESIAN_POINT('',(2.2,10.024,1.));
#736=CARTESIAN_POINT('',(1.536,10.563,2.665));
#737=CARTESIAN_POINT('',(2.226,10.177,1.472));
#738=CARTESIAN_POINT('',(-1.536,10.563,2.665));
#739=CARTESIAN_POINT('Origin',(0.,10.275,1.775));
#740=CARTESIAN_POINT('',(-2.5,10.024,1.));
#741=CARTESIAN_POINT('',(-2.231,10.174,1.465));
#742=CARTESIAN_POINT('',(0.,10.024,1.));
