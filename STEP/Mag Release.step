STEP (ISO 10303-21) file: header records copied from the file, then geometry measured from it (millimetres).
FILE_DESCRIPTION(/* description */ (''),/* implementation_level */ '2;1');
FILE_NAME(/* name */ 'E:/Repos/SP2022-MadamaButterfly/STEP/Mag Release.step',/* time_stamp */ '2021-01-23T03:07:15-05:00',/* author */ (''),/* organization */ (''),/* preprocessor_version */ 'ST-DEVELOPER v18.1',/* originating_system */ 'Autodesk Translation Framework v9.7.1.1290',/* authorisation */ '');
FILE_SCHEMA (('AUTOMOTIVE_DESIGN { 1 0 10303 214 3 1 1 }'));
Length unit declared in the file: millimetre
Products named in the file (1): Mag Release
Bounding box: 30 x 9.23 x 9.25 mm (x, y, z)
Volume: 577 mm3; surface area: 860.6 mm2
Topology: 1 solids, 1 shells, 79 faces, 223 edges, 143 vertices
Faces by surface type: plane 45, cylinder 18, bspline 12, torus 4
Entity records: 3030 total; most frequent: CARTESIAN_POINT 997, ORIENTED_EDGE 438, DIRECTION 401, EDGE_CURVE 219, AXIS2_PLACEMENT_3D 152, VERTEX_POINT 143, LINE 97, VECTOR 97
